FILESEXTRAPATHS:prepend:intel-x86 := "${THISDIR}/${PN}:"
